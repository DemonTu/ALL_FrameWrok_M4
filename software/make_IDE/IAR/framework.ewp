# IAR project framework.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\work\source\ALL_FrameWrok_M4\software\CMSIS\Device\ST\STM32F4xx\Include; C:\work\source\ALL_FrameWrok_M4\software\CMSIS\Include; C:\work\source\ALL_FrameWrok_M4\software\user; C:\work\source\ALL_FrameWrok_M4\software\STM32F4xx_StdPeriph_Driver\inc; C:\work\source\ALL_FrameWrok_M4\software\device\OLED\IIC; C:\work\source\ALL_FrameWrok_M4\software\device\smart_battery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: framework.bin
  ILINK.IlinkOutputFile: framework.out
  ILINK.IlinkIcfFile: framework.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/CMSIS
    ../../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
    ../../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ../../user/: config.h Event.c Event.h I2C_Driver.c includes.h IO.h main.c Main.h Mode_Special.c Mode_Special.h Pollint.c Pollint.h Retarget.c STM32_Flash.scat stm32f4xx_it.c Timer.c Timer.h Usart1.c Usart1.h
  group user/device/OLED
    ../../device/OLED/IIC/: oled.c
  group user/device/Smart_Battery
    ../../device/smart_battery/: I2C_SoftwareDriver.c SmBus_Driver.c
